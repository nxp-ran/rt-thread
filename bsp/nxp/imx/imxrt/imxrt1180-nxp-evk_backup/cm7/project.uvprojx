# Keil uVision project project.uvprojx, settings and files
target rtthread (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20500000,0x040000) IROM(0x00000000,0x028000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __RTTHREAD__, MIMXRT1189_cm7_SERIES, CPU_MIMXRT1189CVM8C_cm7, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, __CLK_TCK=RT_TICK_PER_SECOND, NDEBUG, RT_USING_ARMLIBC, RT_USING_LIBC, FSL_ETH_ENABLE_CACHE_CONTROL=1, __STDC_LIMIT_MACROS, ARM_MATH_CM7, SDK_NETC_USED=1
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include;applications;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm7;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers;.;..\..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\..\components\net\netdev\include;..\..\..\..\..\..\components\drivers\include;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile;board\ports;board;..\..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\..\..\..\components\net\utest;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\..\components\libc\compilers\common\include;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189;..\..\..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\..\..\..\components\net\sal\include;..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\..\components\drivers\phy;..\..\..\..\..\..\components\finsh;..\..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\eventfd;..\..\libraries\drivers;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\net\sal\impl;..\..\..\..\..\..\libcpu\arm\cortex-m7;board\MCUX_Config;..\..\..\..\..\..\include;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph;..\..\..\..\..\..\components\net\sal\include\socket;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\net\lwip\port
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.scf
  group Applications
    applications/: main.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/phy/: phy.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../../libraries/drivers/: drv_common.c drv_netc.c drv_uart.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_pmu.c fsl_clock.c fsl_ele_base_api.c fsl_s3mu.c fsl_trdc.c fsl_gpc.c fsl_memory.c fsl_soc_src.c fsl_rgpio.c fsl_lpuart.c fsl_msgintr.c fsl_netc_ierb.c fsl_netc_timer.c fsl_netc_mdio.c fsl_netc_endpoint.c fsl_netc_soc.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm7.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm7/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/arm/: startup_MIMXRT1189_cm7.s
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/netc_hw/: fsl_netc_hw.c fsl_netc_hw_port.c fsl_netc_hw_si.c fsl_netc_hw_enetc.c
  group lwIP
    ../../../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../../../components/net/sal/socket/: net_netdb.c
    ../../../../../../components/net/sal/src/: sal_socket.c
