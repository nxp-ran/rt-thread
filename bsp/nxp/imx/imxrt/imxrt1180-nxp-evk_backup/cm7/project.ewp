# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1189CVM8C_cm7; MIMXRT1189_cm7_SERIES; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; ARM_MATH_CM7; NDEBUG; SDK_NETC_USED=1; FSL_ETH_ENABLE_CACHE_CONTROL=1; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: applications; ..\..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\..\..\components\drivers\include; ..\..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\..\components\drivers\smp_call; board; board\MCUX_Config; board\ports; ..\..\libraries\drivers; ..\..\..\..\..\..\components\finsh; .; ..\..\..\..\..\..\include; ..\..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\..\components\libc\posix\ipc; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm7; ..\..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif; ..\..\..\..\..\..\components\net\lwip\port; ..\..\..\..\..\..\components\net\netdev\include; ..\..\..\..\..\..\components\net\sal\include; ..\..\..\..\..\..\components\net\sal\include\socket; ..\..\..\..\..\..\components\net\sal\impl; ..\..\..\..\..\..\components\net\sal\include\socket\sys_socket; ..\..\..\..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkConfigDefines: __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/phy/: phy.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../../libraries/drivers/: drv_common.c drv_netc.c drv_uart.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_pmu.c fsl_clock.c fsl_ele_base_api.c fsl_s3mu.c fsl_trdc.c fsl_gpc.c fsl_memory.c fsl_soc_src.c fsl_rgpio.c fsl_lpuart.c fsl_msgintr.c fsl_netc_ierb.c fsl_netc_timer.c fsl_netc_mdio.c fsl_netc_endpoint.c fsl_netc_soc.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm7.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm7/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/iar/: startup_MIMXRT1189_cm7.s
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/netc_hw/: fsl_netc_hw.c fsl_netc_hw_port.c fsl_netc_hw_si.c fsl_netc_hw_enetc.c
  group lwIP
    ../../../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../../../components/net/sal/socket/: net_netdb.c
    ../../../../../../components/net/sal/src/: sal_socket.c
