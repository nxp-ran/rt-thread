# Keil uVision project project.uvprojx, settings and files
target rtthread (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP ELITTLE
  output: rtthread +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1189CVM8C_cm33, __USE_SHMEM, NDEBUG, ARM_MATH_CM33, MIMXRT1189_cm33_SERIES, RT_USING_LIBC, MULTICORE_APP=1, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, MCUXPRESSO_SDK, MCUX_META_BUILD, RT_USING_ARMLIBC
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\..\components\drivers\phy;board\ports;multicore;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\poll;multicore\mcmgr\inc\platform\imxrt1180;..\..\..\..\..\..\include;..\..\..\..\..\..\components\drivers\include;..\..\libraries\drivers;board;..\..\..\..\..\..\components\libc\compilers\common\include;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include;applications;xip;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm33;..\..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\..\components\net\utest;..\..\..\..\..\..\components\libc\posix\io\eventfd;multicore\mcmgr\inc;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\..\libcpu\arm\common;.;..\..\..\..\..\..\libcpu\arm\cortex-m33;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189;..\..\..\..\..\..\components\finsh;board\MCUX_Config;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\smp_call
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm33_ram.scf
  link misc: --predefine="-D__use_shmem__=1" --predefine="-D__multicore__=1"
  group Applications
    applications/: main.c multicore_thread.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../../libraries/drivers/: drv_common.c drv_uart.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_pmu.c fsl_clock.c fsl_ele_base_api.c fsl_s3mu.c fsl_trdc.c fsl_gpc.c fsl_memory.c fsl_soc_src.c fsl_rgpio.c fsl_lpuart.c fsl_edma.c fsl_edma_soc.c fsl_lpuart_edma.c fsl_mu.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm33.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm33/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/arm/: startup_MIMXRT1189_cm33.s
  group MultiCore
    multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c
  group xip
    xip/: evkmimxrt1180_flexspi_nor_config.c fsl_flexspi_nor_boot.c
