# IAR project project.ewp, settings and files
configuration rtthread_ram (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1189CVM8C_cm7; MIMXRT1189_cm7_SERIES; ARM_MATH_CM7; NDEBUG; __USE_SHMEM; MULTICORE_APP=1; XIP_EXTERNAL_FLASH=1; XIP_EXTERNAL_FLASH=1; LFS_CONFIG=lfs_config.h; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\..\..\components\drivers\include; ..\..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\..\components\drivers\smp_call; board; board\MCUX_Config; board\ports; ..\..\libraries\drivers; ..\..\..\..\..\..\components\fal\inc; ..\..\..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\..\..\components\finsh; .; ..\..\..\..\..\..\include; ..\..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\..\components\libc\posix\ipc; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm7; packages\littlefs-latest; multicore; multicore\mcmgr\inc; multicore\mcmgr\inc\platform\imxrt1180; ..\..\..\..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkConfigDefines: __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rtthread_hyperram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\0.RanChen\2.Projects\RT-Thread\rt-thread_pr\rt-thread\bsp\nxp\imx\imxrt\imxrt1180-nxp-evk\cm7\board\linker_scripts\MIMXRT1189xxxxx_cm7_hyperram.icf
configuration rtthread_flexspi_nor (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkIcfFile: C:\0.RanChen\2.Projects\RT-Thread\rt-thread_pr\rt-thread\bsp\nxp\imx\imxrt\imxrt1180-nxp-evk\cm7\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor.icf
configuration rtthread_flexspi_nor_hyperram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\0.RanChen\2.Projects\RT-Thread\rt-thread_pr\rt-thread\bsp\nxp\imx\imxrt\imxrt1180-nxp-evk\cm7\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_hyperram.icf
  group Applications
    applications/: main.c mnt.c multicore_thread.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/mtd/: mtd_nor.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../../libraries/drivers/: drv_common.c drv_flexspi.c drv_uart.c
    board/ports/: drv_flexspi_nor_flash.c fal_flash_port.c
  group Fal
    ../../../../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    ../../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../../components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm7/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_ecat.c fsl_ele_base_api.c fsl_flexspi.c fsl_gpc.c fsl_gpt.c fsl_lpuart.c fsl_memory.c fsl_mu.c fsl_pmu.c fsl_rgpio.c fsl_s3mu.c fsl_soc_src.c fsl_trdc.c fsl_xbar.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/iar/: startup_MIMXRT1189_cm7.s
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm7.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group MultiCore
    multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c
