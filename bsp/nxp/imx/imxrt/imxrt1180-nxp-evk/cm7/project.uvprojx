# Keil uVision project project.uvprojx, settings and files
target rtthread_ram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20500000,0x040000) IROM(0x00000000,0x028000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, MIMXRT1189_cm7_SERIES, RT_USING_LIBC, ARM_MATH_CM7, __USE_SHMEM, XIP_EXTERNAL_FLASH=1, RT_USING_ARMLIBC, CPU_MIMXRT1189CVM8C_cm7, NDEBUG, LFS_CONFIG=lfs_config.h, __STDC_LIMIT_MACROS, __RTTHREAD__, MULTICORE_APP=1
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: applications;..\..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\..\components\fal\inc;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph;multicore\mcmgr\inc;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile;..\..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\..\components\drivers\include;multicore;..\..\..\..\..\..\components\libc\compilers\common\extension;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm7;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\net\utest;..\..\libraries\drivers;..\..\..\..\..\..\include;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\..\components\drivers\phy;..\..\..\..\..\..\components\finsh;board\MCUX_Config;multicore\mcmgr\inc\platform\imxrt1180;..\..\..\..\..\..\components\libc\posix\io\poll;board;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers;..\..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\..\components\drivers\include;packages\littlefs-latest;board\ports;..\..\..\..\..\..\components\dfs\dfs_v1\include;.;..\..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\include
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.scf
  link misc: --predefine="-D__use_shmem__=1" --predefine="-D__multicore__=1"
  group Applications
    applications/: main.c multicore_thread.c mnt.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/mtd/: mtd_nor.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    board/ports/: drv_flexspi_nor_flash.c fal_flash_port.c
    ../../libraries/drivers/: drv_common.c drv_flexspi.c drv_uart.c
  group Fal
    ../../../../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    ../../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_pmu.c fsl_clock.c fsl_ele_base_api.c fsl_s3mu.c fsl_trdc.c fsl_gpc.c fsl_memory.c fsl_soc_src.c fsl_rgpio.c fsl_lpuart.c fsl_mu.c fsl_gpt.c fsl_ecat.c fsl_xbar.c fsl_flexspi.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm7.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm7/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/arm/: startup_MIMXRT1189_cm7.s
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group MultiCore
    multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c
target rtthread_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: as above
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_hyperram.scf
  link misc: as above
target rtthread_flexspi_nor (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: as above
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor.scf
  link misc: as above
target rtthread_flexspi_nor_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: as above
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_hyperram.scf
  link misc: as above
